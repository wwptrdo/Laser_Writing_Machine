# Keil uVision project 激光雕刻兼写字机器下位机程序final_测试版.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 激光雕刻兼写字机器下位机程序final_测试版 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 激光雕刻兼写字机器下位机程序final_测试版.c
